
require python3-usbsdmux.inc

SRCBRANCH = "master"
SRCREV = "dc8ea0ea05cd1cf02902fbfebf79061389a69097"
